FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-sdmmc1-fix.patch"
SRC_URI += "file://0002-wilc1000.patch"

