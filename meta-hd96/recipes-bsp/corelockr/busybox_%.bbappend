ALTERNATIVE_PRIORITY[tee] = "100"

ALTERNATIVE_TARGET[tee] = "${bindir}/tee"
ALTERNATIVE_LINK_NAME[tee] = "${base_bindir}/busybox.nosuid"

