ALTERNATIVE_PRIORITY[tee] = "50"

