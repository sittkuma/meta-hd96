FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI += "file://0001-hotspot-os-support.patch"

