BBCLASSEXTEND += " nativesdk"

